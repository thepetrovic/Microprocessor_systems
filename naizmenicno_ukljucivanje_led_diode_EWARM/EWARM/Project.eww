<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\naizmenicno_ukljucivanje_led_diode_EWARM.ewp</path>
  </project>
  <batchBuild />
</workspace>
