<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Binarni_brojac_EWARM.ewp</path>
  </project>
  <batchBuild />
</workspace>
